** sch_path: xschem/tb/cs.sch
**.subckt cs in out
*.ipin in
*.opin out
R1 VDD out 1k m=1
M1 out in GND GND nch w=3.6u l=0.18u m=1
**.ends
.GLOBAL VDD
.GLOBAL GND
.end
