** sch_path: xschem/MOSFET/gf180mcu_pfet_03v3_idvds.sch
**.subckt gf180mcu_pfet_03v3_idvds
Vgs GND net2 1.0
Vds GND net1 3.3
XM1 net1 net2 GND GND pfet_03v3 L=0.28u W=2.8u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
**** begin user architecture code

.option savecurrents
.control
save all
save @m.xm1.m0[gds]
dc Vds 0 3.3 0.02
let vds=v(vds)
plot -i(vds)
plot 1/@m.xm1.m0[gds]
plot @m.xm1.m0[gds]/vds
wrdata gf180mcu_pfet_03v3_idvds_id.txt -i(vds)
wrdata gf180mcu_pfet_03v3_idvds_rds.txt -i(vds)
.endc

[
set gf180mcu_corner(typical) "
.include /foss/pdks/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuC/libs.tech/ngspice/sm141064.ngspice typical
"
set gf180mcu_corner(sf) "
.include /foss/pdks/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuC/libs.tech/ngspice/sm141064.ngspice sf
"
set gf180mcu_corner(ff) "
.include /foss/pdks/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuC/libs.tech/ngspice/sm141064.ngspice ff
"
set gf180mcu_corner(ss) "
.include /foss/pdks/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuC/libs.tech/ngspice/sm141064.ngspice ss
"
set gf180mcu_corner(fs) "
.include /foss/pdks/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuC/libs.tech/ngspice/sm141064.ngspice typical fs
"
return $gf180mcu_corner(typical)]
**** end user architecture code
**.ends
.GLOBAL GND
.end
