** sch_path: xschem/MOSFET/gf180mcu_pfet_03v3_igain.sch
**.subckt gf180mcu_pfet_03v3_igain
Vgs gate GND 1.65
Vdd VDD GND 3.3
F1 out1 GND vds1 -1
Vds vds GND 1.65
Vac ac_in gate DC 0 AC 1
Vds1 vds net1 0
XM1 out1 ac_in VDD VDD pfet_03v3 L=pfet_l W=pfet_w nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM2 net1 gate VDD VDD pfet_03v3 L=pfet_l W=pfet_w nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
F2 out2 GND vds2 -1
Vds2 vds net2 0
XM3 out2 ac_in VDD VDD pfet_03v3 L=pfet_l *2 W=pfet_w *2 nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM4 net2 gate VDD VDD pfet_03v3 L=pfet_l *2 W=pfet_w *2 nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
F3 out4 GND vds4 -1
Vds4 vds net3 0
XM5 out4 ac_in VDD VDD pfet_03v3 L=pfet_l *4 W=pfet_w *4 nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM6 net3 gate VDD VDD pfet_03v3 L=pfet_l *4 W=pfet_w *4 nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
F4 out8 GND vds8 -1
Vds8 vds net4 0
XM7 out8 ac_in VDD VDD pfet_03v3 L=pfet_l *8 W=pfet_w *8 nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM8 net4 gate VDD VDD pfet_03v3 L=pfet_l *8 W=pfet_w *8 nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
F5 out16 GND vds16 -1
Vds16 vds net5 0
XM9 out16 ac_in VDD VDD pfet_03v3 L=pfet_l *16 W=pfet_w *16 nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XM10 net5 gate VDD VDD pfet_03v3 L=pfet_l *16 W=pfet_w *16 nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
**** begin user architecture code
[
set gf180mcu_corner(typical) "
.include /foss/pdks/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuC/libs.tech/ngspice/sm141064.ngspice typical
"
set gf180mcu_corner(sf) "
.include /foss/pdks/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuC/libs.tech/ngspice/sm141064.ngspice sf
"
set gf180mcu_corner(ff) "
.include /foss/pdks/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuC/libs.tech/ngspice/sm141064.ngspice ff
"
set gf180mcu_corner(ss) "
.include /foss/pdks/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuC/libs.tech/ngspice/sm141064.ngspice ss
"
set gf180mcu_corner(fs) "
.include /foss/pdks/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /foss/pdks/gf180mcuC/libs.tech/ngspice/sm141064.ngspice fs
"
return $gf180mcu_corner(typical)]

.option savecurrents
.control
save all
ac dec 20 1e6 1e11
plot vdb(out1) vdb(out2) vdb(out4) vdb(out8) vdb(out16)
wrdata gf180mcu_pfet_03v3_igain_g.txt vdb(out1) vdb(out2) vdb(out4) vdb(out8) vdb(out16)
.endc


.param pfet_l=0.28u
.param pfet_w=2.8u


.measure ac Gi1 find vdb(out1) at=1e6
.measure ac UGF1 when vdb(out1)=0 from=1e6
.measure ac Gi2 find vdb(out2) at=1e6
.measure ac UGF2 when vdb(out2)=0 from=1e6
.measure ac Gi4 find vdb(out4) at=1e6
.measure ac UGF4 when vdb(out4)=0 from=1e6
.measure ac Gi8 find vdb(out8) at=1e6
.measure ac UGF8 when vdb(out8)=0 from=1e6
.measure ac Gi16 find vdb(out16) at=1e6
.measure ac UGF16 when vdb(out16)=0 from=1e6

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
